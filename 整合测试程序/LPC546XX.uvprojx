# Keil uVision project LPC546XX.uvprojx, settings and files
target LPC546XX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54606J512BD208:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LPC546XX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\Chip\inc;.\Startup;.\Startup\DeviceSupport;.\Startup\CoreSupport;.\Board
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  group User
    ./User/: isr.c main.c LPC546XX_config.h headfile.h menu.c ImageProcess.c SelfBuild_control.c SelfBuild_PID.c SelfBuild_Electron_Calcu.c SelfBuild_correct_sensor.c VCAN_computer.c
  group Board
    ./Board/: inv_mpu.c inv_mpu_dmp_motion_driver.c LPC546XX_myiic.cpp LPC546XX_mpu6050.c LPC546XX_myspi.c LPC546XX_mcp41.c LPC546XX_oled.c SEEKFREE_MT9V032.c
  group Chip
    ./Chip/src/: assert.c common.c LPC546XX_adc.c LPC546XX_ctimer.c LPC546XX_dma.c LPC546XX_eeprom.c LPC546XX_flexcomm.c LPC546XX_gint.c LPC546XX_gpio.c LPC546XX_iic.c LPC546XX_iocon.c LPC546XX_mrt.c LPC546XX_pint.c LPC546XX_pit.c LPC546XX_pll.c LPC546XX_sct.c LPC546XX_spi.c LPC546XX_systick.c LPC546XX_uart.c misc.c
  group Startup
    ./Startup/DeviceSupport/MDK-ARM/: startup_LPC54606.s
    ./Startup/DeviceSupport/: system_LPC54606.c
